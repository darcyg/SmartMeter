# IAR project Backup (8) of emeter-6733.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F6736 MSP430F6736
  General.GStackSize2: 300
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CUSTOM_EMETER_H="emeter-1ph-neutral-6733_shunt.h"; X_ZEBU_
  ICC430.newCCIncludePaths: ../emeter-toolkit
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F6736.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: emeter-background.c emeter-basic-display.c emeter-communication.c emeter-dlt645.c emeter-fir-table.c emeter-foreground.c emeter-iiceeprom.c emeter-main.c emeter-multirate.c emeter-phase-corrections.c emeter-rtc.c emeter-setup.c hal_pmm.c hal_UCS.c
    ../emeter-toolkit/Debug/Exe/: emeter-toolkit-6733.r43
