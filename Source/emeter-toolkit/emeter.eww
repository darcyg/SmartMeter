<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\emeter-ng\emeter-6733.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\emeter-toolkit-6733.ewp</path>
  </project>
  <batchBuild/>
</workspace>


